# Keil uVision project keaz128keilproject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: keaz128keilproject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TRK_KEA128,CPU_KEA128,KEIL,DEBUG_PRINT
  c include: ..\mcu\inc;..\usr\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\bsp;..\common;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group startup
    ../mcu/startup/: startup_SKEAZ1284.s system_SKEAZ1284.c
  group usr
    ../usr/source/: main.c led.c
  group bsp
    ../bsp/: HalADC.c HalIO.c HalUart.c
  group UCOS II
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group drive
    ../driver/: acmp.c adc.c crc.c flash.c ftm.c ics.c kbi.c mscan.c pit.c pmc.c pwt.c rtc.c spi.c uart.c wdog.c
  group common
    ../common/: arm_cm0.c assert.c
